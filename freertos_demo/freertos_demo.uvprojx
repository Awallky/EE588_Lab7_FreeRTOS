# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_demo
  AfterMake: fromelf --bin --output .\rvmdk\freertos_demo.bin .\rvmdk\freertos_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: .;..\FreeRTOS\Source\include;..\TI;..\TI\examples/boards\ek-tm4c123gxl;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: freertos_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: freertos_demo.c led_task.c switch_task.c BSP.c startup_rvmdk.S accelerometer_task.c
  group Libraries
    ../ti/TivaWare_C_Series-2.1.4.178/driverlib/: driverlib.lib
  group Documentation
    ./: readme.txt
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group TI Drivers
    ../ti/TivaWare_C_Series-2.1.4.178/examples/boards/ek-tm4c123gxl/drivers/: buttons.c rgb.c
  group TI Utils
    ../ti/TivaWare_C_Series-2.1.4.178/utils/: ustdlib.c uartstdio.c
software components: CMSIS:CORE 5.0.1
